# IAR project stm32f415project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_STM322xG_EVAL
  ICCARM.CCIncludePath2: ; system; sources; STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f415project.srec
  ILINK.IlinkOutputFile: stm32f415project.out
  ILINK.IlinkIcfFile: stm32f415project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group sources
    sources/: adpcm_coder.c config.c i2c_f207.c i2c_f207.h main.c main.h spi_f207.c spi_f207.h spi_pga112.c spi_pga112.h transmit_handler.c
  group stm_lib
    STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c
  group system
    system/: startup_stm32f4xx.s system_stm32f4xx.c
