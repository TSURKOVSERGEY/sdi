# IAR project stm32f207project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL
  ICCARM.PreInclude: sources\preinclude.h
  ICCARM.CCIncludePath2: ; system; sources; ETH; STM32F2xx_StdPeriph_Driver\inc; lwip_v1.3.2\port\STM32F2x7; lwip_v1.3.2\src\include; lwip_v1.3.2\src\include\ipv4; lwip_v1.3.2\src\include\ipv6; lwip_v1.3.2\port\STM32F2x7\Standalone; lwip_v1.3.2\src\netif
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f207project.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f207project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group eth
    lwip_v1.3.2/src/include/: lwipopts.h
    ETH/: stm32f2x7_eth.c stm32f2x7_eth_bsp.c stm32f2x7_eth_bsp.h
  group lwip
    lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    lwip_v1.3.2/src/core/: dhcp.c mem.c memp.c netif.c pbuf.c raw.c tcp.c tcp_in.c tcp_out.c udp.c
    lwip_v1.3.2/src/netif/: etharp.c netconf.c
    lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
    STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_exti.c
  group sources
    sources/: at24c512.c at24c512.h cmd_handler.c config.c debug.c debug.h ethernet.c ethernet.h main.c main.h nand_hw_driver.c nand_hw_driver.h nand_sb_config_driver.c nand_sb_read_driver.c nand_sb_write_driver.c sntp.c spi_f207.c spi_f207.h spi_rxDMA_handler.c spi_rxIRQ_handler.c test.c
    STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_rtc.c
  group stm_lib
    STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_crc.c stm32f2xx_dma.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_tim.c
  group system
    system/: startup_stm32f2xx.s system_stm32f2xx.c
