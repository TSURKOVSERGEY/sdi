# IAR project stm32l151project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xB ST STM32L151xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L15XXB_128K
  ICCARM.PreInclude: system\preinclude.h
  ICCARM.CCIncludePath2: ; system; sources; STM32L1xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32l151project.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32l151project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    system/: startup_stm32l1xx_md.s
  group sources
    sources/: adpcm_coder.c config.c i2c_f207.c i2c_f207.h main.c main.h spi_f207.c spi_f207.h spi_pga112.c spi_pga112.h transmit_handler.c
  group stm_lib
    STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_crc.c stm32l1xx_dma.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_tim.c
  group system
    system/: system_stm32l1xx.c
